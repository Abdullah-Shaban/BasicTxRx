<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_application</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>digital_gain</value></param>
<param><key>value</key><value>1.0/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[1,-1,1,-1,1,1,-1,-1,1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,-1,1,1,1,-1,-1,-1,1,-1,1,1,1,1,-1,-1,1,-1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rf_freq</value></param>
<param><key>value</key><value>2495000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>crew_packet_gen</key>
<param><key>id</key><value>crew_packet_gen_0</value></param>
<param><key>gap</key><value>gap</value></param>
<param><key>packet_len</key><value>payload_size</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>usrp_rf_freq+fine_freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>J1</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>label</key><value>payload size in byte</value></param>
<param><key>value</key><value>500</value></param>
<param><key>start</key><value>50</value></param>
<param><key>stop</key><value>500</value></param>
<param><key>step</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>usrp_rf_freq+fine_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-120</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fine_freq</value></param>
<param><key>label</key><value>Fine Frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-10e3</value></param>
<param><key>stop</key><value>10e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gap</value></param>
<param><key>label</key><value>Interpacket interval (in samples)</value></param>
<param><key>value</key><value>20000</value></param>
<param><key>start</key><value>100</value></param>
<param><key>stop</key><value>50000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>digital_gain</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/users/lwei/GITfolder/wirelessacademy/BasicTx/wilabt/file_sent.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Tx Gain</value></param>
<param><key>value</key><value>26</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crew_packet_gen_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>crew_packet_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
